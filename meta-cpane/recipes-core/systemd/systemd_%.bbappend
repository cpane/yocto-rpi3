do_install:append() {
    install -d ${D}${nonarch_libdir}/udev
}

